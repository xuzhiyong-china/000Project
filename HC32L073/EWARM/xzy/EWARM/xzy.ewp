# IAR project xzy.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\mcu\common; ..\source; ..\..\..\driver\inc; ..\..\..\midware\inc; C:\000xuzhiyong\File\000Project\HC32L073\midware\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: HC32L07X.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\mcu\common; ..\source; ..\..\..\driver\inc; ..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  group common
    ../../../driver/src/: ddl.c
    ../../../mcu/common/: interrupts_hc32l07x.c system_hc32l07x.c
    ./: startup_hc32l07x.s
  group driver
    ../../../driver/src/: sysctrl.c
  group midware
    ../../../midware/src/: global.c systemclock.c WS2812.c
  group README
    ../: Readme.txt
  group source
    ../source/: main.c
